# Repository paretech/ps1

File README.md:

# ps1.git

ps1 is a dual polarity (+/- 15V) full wave rectified power supply. Schematic capture and PCB layout conducted in KiCad.

Some [requirements](../../wiki/Requirements) are in the works over in the [wiki](../../wiki).

## KiCad design kicad/ps1.kicad_pcb

Parts:
C1: 0.1uF; Resistor_Horizontal_RM10mm
C2, C3, C4, C5: 8200uF; C_Radial_D35_L51_P10
C6: .33uF; C_Disc_D7.5_P5
C7: 2.2uF; C_Disc_D7.5_P5
C8: 0.1uF; C_Disc_D7.5_P5
C9: 1uF; C_Disc_D12_P7.75
C10: SPARE; C_Radial_D6.3_L11.2_P2.5
C11: 220uF; C_Radial_D6.3_L11.2_P2.5
D1: 6A, 400V; Diode_Bridge_18.5x5.5
D2, D3: 1N4004; Diode_DO-41_SOD81_Horizontal_RM10
D4, D5: 1N5822; Diode_DO-41_SOD81_Horizontal_RM10
D6, D7: LED; LED_0805
P1, P2: CONN_01X03; Molex_Mini-Fit_JR-5566-03x3x
R1: 20; Resistor_Horizontal_RM25mm
R2, R3: R; Resistor_Ceramic_Horizontal_L23mm-W9mm-H9mm-p30mm
R6, R7: R; R_0805_HandSoldering
U1: LM7815ACT; TO-220
U2: LM7918ACT; TO-220

Connections:
/+15V: C8.1, C10.1, D2.2 (A), D4.1 (K), P2.1, R6.1, U1.3 (OUT)
/+18V: C1.1, D1.4, P1.1
/-15V: C9.2, C11.2, D3.2 (A), D5.2 (A), D7.1, P2.3, U2.3 (OUT)
/-18V: D1.2, P1.3, R1.2
/GND: C2.2, C3.1, C4.2, C5.1, C6.2, C7.1, C8.2, C9.1, C10.2, C11.1, D4.2 (A), D5.1 (K), D6.1, P1.2, P2.2, R2.2, R3.1, R7.1, U1.2 (GND), U2.1 (GND)
unnamed: C1.2, R1.1
unnamed: C2.1, C4.1, C6.1, D1.3 (+), D2.1 (K), R2.1, U1.1 (IN)
unnamed: C3.2, C5.2, C7.2, D1.1 (-), D3.1 (K), R3.2, U2.2 (IN)
unnamed: D6.2, R6.2
unnamed: D7.2, R7.2

Notes on the sheet:
Filter Network
Damping Network
Diode Bridge
Min. Load Bleeders
Reverse Protection
Discharge Protection
Bypass
Filter
Release History
Rev.
Description
Engineer
Date
C1 - C4: Rubycon 8200µF 80V Aluminum Capacitors Radial, Can - Snap-In 3000 Hrs @ 85°C (80USC8200MEFCSN35X45) C6: A 0.33 uF or larger tantalum, mylar or other capacitor having low internal impedance at high frequencies should be chosen. C7: A 2.2 uF must be solid tantalum. If aluminium electrolytic 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
Power Indicators
Mating Receptacle Molex Mini-Fit Single Row Receptacle 39-01-4031

Board: 2 copper layers, 152.4 x 139.7 mm, 27 parts (0 on the bottom side), 10 nets.

## Commit log

2016-12-26 Created new repot and README.
2016-12-26 Added ignore file
2016-12-26 Initial design commit of dual polarity (+/- 15V) full wave rectified power supply. Note, the annitations and values are not correct. Ended up doing a redesign and for better or worse did a lot of C&P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
2016-12-26 Renamed project from test to ps1
2016-12-26 Cleared annotations, cleaned up annotations, added history block, modified title block. Component values do not indicate design parameters, all should be considered TBD.
2016-12-26 Restructured directory and added some images
2016-12-27 Update README.md
    Added image and very brief description to README
2016-12-27 Update README.md
    Added links to wiki
2016-12-28 Annotated, regenerated plot
2017-01-02 Modified gitignore to exclude folder Datasheets as not redistributable in most cases.
2017-01-02 Removed power entry block as preparing for pcb layout.
2017-01-02 Replaced output connectors and assigned footprint.
2017-01-02 Removed transient suppressor and added transformer receptacle. Transient suppressor was removed because this board is designed to be all cold side. Use shrink tube wrapped mini board to inline suppre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
2017-01-03 Minor updates as picking BOM
2017-01-10 Various schematic, pcb and footprint modifications. PCB layout left in first schematic order rough fit. Very large layout, need to get creative and find enclosure.
2017-01-12 Umm, it has been a while since I committed to something.
2017-01-16 New case and new layout.
2018-11-02 Update README.md
    Updated image link, server URL appears to have changed for raw?
2018-11-02 Update README.md
    Attempt 2 at fixing SVG gfx render. See details at https://stackoverflow.com/questions/13808020/include-an-svg-hosted-on-github-in-markdown
